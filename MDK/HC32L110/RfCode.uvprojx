# Keil uVision project RfCode.uvprojx, settings and files
target HD_RF_Code (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L110C6UA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HD_RF_Code +hex
  c flags: Optim=3 OneElfS=1
  c include: ..\..\Code\ap\inc;..\..\Code\bsp;..\..\Code\bsp\HC32L110\inc;..\..\Code\lib_drv\HC32L110\driver\inc;..\..\Code\lib_drv\HC32L110\mcu\common;..\..\Code\modules;..\..\Code\modules\key\inc;..\..\Code\modules\pwrManager\inc;..\..\Code\modules\radio\inc;..\..\Code\sys;..\..\Code\sys\qep\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group ap
    ../../Code/ap/src/: main.c app_radio.c app_uart.c debug.c SceneInstance.c app_main.c app_rtc.c
  group bsp
    ../../Code/bsp/HC32L110/src/: board.c hal_adc.c hal_flash.c hal_gpio.c hal_rtc.c hal_subghz.c hal_tick.c hal_tim_.c hal_uart.c hal_watchdog.c
  group lib_drv
    ../../Code/lib_drv/HC32L110/driver/src/: adc.c adt.c bt.c clk.c crc.c ddl.c flash.c gpio.c i2c.c interrupts_hc32l110.c lpm.c lpt.c lpuart.c lvd.c pca.c reset.c rtc.c spi.c trim.c uart.c vc.c wdt.c
    ../../Code/lib_drv/HC32L110/mcu/common/: system_hc32l110.c startup_hc32l110.s
  group modules
    ../../Code/modules/key/src/: Key.c
    ../../Code/modules/pwrmanager/src/: PwrManager.c
    ../../Code/modules/radio/src/: radio_2300a.c radio_2300a_driver.c
  group sys
    ../../Code/sys/: event.c list.c polling.c qep_port.c system.c
    ../../Code/sys/qep/src/: qep.c qeq_fifo.c qfsm_dis.c
software components: CMSIS:CORE 5.3.0
