# Keil uVision project RfCode.uvprojx, settings and files
target HD_RF_Code (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BAT32G133GC24SS Cmsemicon
  pack: Cmsemicon.BAT32G133.1.1.3
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x08000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ZW_RF_Code +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\Code\bsp\BAT32G133\inc;..\..\Code\lib_drv\BAT32G133\mcu;..\..\Code\lib_drv\BAT32G133\driver\inc;..\..\Code\ap\inc;..\..\Code\bsp;..\..\Code\modules;..\..\Code\modules\key\inc;..\..\Code\modules\pwrManager\inc;..\..\Code\modules\radio\inc;..\..\Code\sys;..\..\Code\sys\qep\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group ap
    ../../Code/ap/src/: main.c app_radio.c app_uart.c debug.c SceneInstance.c app_main.c app_rtc.c
  group bsp
    ../../Code/bsp/Bat32G133/src/: board.c hal_adc.c hal_flash.c hal_gpio.c hal_rtc.c hal_subghz.c hal_tick.c hal_tim_.c hal_uart.c hal_watchdog.c
  group lib_drv
    ../../Code/lib_drv/BAT32G133/driver/src/: adc.c adc_user.c clk.c cmp.c cmp_user.c dma.c elc.c flash.c flash_user.c gpio.c iica.c iica_user.c intp.c intp_user.c pcbz.c pga.c retarget.c rst.c rtc.c rtc_user.c sci.c sci_user.c tim4.c tim4_user.c wdt.c wdt_user.c
  group modules
    ../../Code/modules/key/src/: Key.c
    ../../Code/modules/pwrmanager/src/: PwrManager.c
    ../../Code/modules/radio/src/: radio_2300a.c radio_2300a_driver.c
  group sys
    ../../Code/sys/: event.c list.c polling.c qep_port.c system.c
    ../../Code/sys/qep/src/: qep.c qeq_fifo.c qfsm_dis.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
